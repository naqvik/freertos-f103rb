# Keil uVision project freertos1.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: freertos1
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ./app/include;./FreeRTOS-Kernel/include;./FreeRTOS-Kernel/portable/GCC/ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ./app/: simple.cpp
  group freertos-gcc-arm-cm3
    ./FreeRTOS-Kernel/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./FreeRTOS-Kernel/portable/GCC/ARM_CM3/: port.c
    ./FreeRTOS-Kernel/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
